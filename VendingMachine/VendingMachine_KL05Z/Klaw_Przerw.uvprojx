# Keil uVision project Klaw_Przerw.uvprojx, settings and files
target KL05Z (6190000::V6.19::ARMCLANG)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Klaw_Przerw
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group src
    ./: i2c.c klaw.c lcd1602.c main.c leds.c tsi.c tsi.h uart0.c uart0.h
    ../../Zad5_1bJG (1)/3_UART0_Sterowanie/: led.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
